Commit message: 14-11

File: motion_imitation/robots/urdf_robot/spot/spot_0611.urdf (robot description, URDF)
Before this commit: robot spot, 17 links, 16 joints
Links:
- link chassis: mass 1.26277058878881 -> 13.715
